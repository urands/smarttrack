# Keil uVision project smarttrack.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smarttrack
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: main.c retarget.c
  group gpio
    ./gpio/: gpio.c ctrl.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_usart.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F103RE/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
  group ::Drivers
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: I2C_STM32F10x.c SPI_STM32F10x.c UART_STM32F10x.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, CMSIS:RTOS:Keil RTX 4.74.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0, Drivers:I2C 1.01.0, Drivers:SPI 1.03.0, Drivers:UART 1.01.0, Drivers:USB Host 1.0.0
